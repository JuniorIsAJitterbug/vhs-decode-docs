options:
  parameters:
    author: VideoMem
    copyright: ( ͡° ͜ʖ ͡°)
    generate_options: qt_gui
    id: vtr
    output_language: python
    title: VTR Luma decoder
  states: {}

blocks:
- name: Fcc_Fcl
  id: variable
  parameters:
    value: 455/80
  states: {}
- name: Fh
  id: variable
  parameters:
    value: 15.625e3
  states: {}
- name: Fv
  id: variable
  parameters:
    value: 25*2
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: round(48e3*4)
  states: {}
- name: auto_luma_gain
  id: variable_function_probe
  parameters:
    block_id: luma_gain_signal
    function_name: level
    poll_rate: samp_rate
    value: '0.1'
  states: {}
- name: chroma_adjusted
  id: variable
  parameters:
    value: if_lo_reference_fc+chroma_fine+chroma_coarse
  states: {}
- name: chroma_coarse
  id: variable_qtgui_range
  parameters:
    comment: '-4360'
    gui_hint: tabs@0
    label: Coarse
    orient: Qt.Horizontal
    start: '-5e3'
    step: '1'
    stop: 1e3
    value: '0'
  states: {}
- name: chroma_fine
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Fine
    orient: Qt.Horizontal
    start: '-1'
    step: '0.0001'
    stop: '1'
    value: '0'
  states: {}
- name: comb_delay
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: Comb filter delay
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: samp_rate/luma_fm_carrier
    value: samp_rate/(luma_fm_carrier*4)
  states: {}
- name: comb_delay_0
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 4*samp_rate/luma_fm_carrier
    value: '5'
  states: {}
- name: comb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: Comb gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '0.2'
    value: '0.1'
  states: {}
- name: disp_height
  id: variable
  parameters:
    value: '625'
  states: {}
- name: disp_width
  id: variable
  parameters:
    value: '1856'
  states: {}
- name: display_scale
  id: variable
  parameters:
    value: samples_per_line / disp_width
  states: {}
- name: fh_comb_delay
  id: variable
  parameters:
    value: samp_rate/(Fh*8)
  states: {}
- name: if_lo_reference_fc
  id: variable
  parameters:
    value: 40*Fh+(Fh/8)
  states: {}
- name: in_rate
  id: variable
  parameters:
    value: 35.8e6
  states: {}
- name: interpolator
  id: variable
  parameters:
    value: '2'
  states: {}
- name: line_average
  id: variable
  parameters:
    value: '2'
  states: {}
- name: lines_per_field
  id: variable
  parameters:
    value: lines_per_frame/2
  states: {}
- name: lines_per_frame
  id: variable
  parameters:
    value: '625'
  states: {}
- name: luma_fm_carrier
  id: variable
  parameters:
    value: Fh * (284-1/4) + Fh/625
  states: {}
- name: luma_fm_carrier_filter_peak
  id: variable
  parameters:
    value: 5.4886e6
  states: {}
- name: luma_min_probe
  id: variable_function_probe
  parameters:
    block_id: luma_min
    function_name: level
    poll_rate: samp_rate
    value: '0'
  states: {}
- name: one_line_samples
  id: variable
  parameters:
    value: nearest.power(samp_rate/Fh,2)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: in_rate*interpolator
  states: {}
- name: samples_per_frame
  id: variable
  parameters:
    value: samp_rate/(interpolator*Fv)
  states: {}
- name: samples_per_line
  id: variable
  parameters:
    value: samp_rate/(interpolator*Fh)
  states: {}
- name: sharpener
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: Sharpness
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '0.2'
    value: '0.06'
  states: {}
- name: vco_center
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@3
    orient: Qt.Horizontal
    start: '-500e3'
    step: '1'
    stop: 500e3
    value: '0'
  states: {}
- name: vco_deviation
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: 10/Fh
    decay_rate: 10/Fh
    gain: '1'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '1.25e-6'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate
    tau: '1.25e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*vco_deviation/8.0)
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '0'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: '10'
    lo: '0.01'
  states: {}
- name: analog_rail_ff_0_0_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-10'
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: '20'
    lo: '0'
  states: {}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: luma_fm_carrier + 100e3
    low_cutoff_freq: luma_fm_carrier - 100e3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 100e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: '-luma_min_probe'
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: round(comb_delay)
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /home/sebastian/Downloads/exports/multiburst_mono.f32
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/sebastian/Downloads/VTR/vhs_pal_multiburst_cropped/vhs_pal_sp_multiburst.r8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: one_line_samples*line_average
    vlen_out: '1'
  states: {}
- name: blocks_min_xx_0
  id: blocks_min_xx
  parameters:
    type: float
    vlen: one_line_samples*line_average
    vlen_out: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: line_average*100
    max_iter: '4000'
    scale: 1/(line_average*100)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: line_average*100
    max_iter: '4000'
    scale: 1/(line_average*100)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_6
  id: blocks_multiply_const_vxx
  parameters:
    comment: auto_luma_gain
    const: auto_luma_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_7_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '255'
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: one_line_samples*line_average
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: one_line_samples*line_average
    type: float
  states: {}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: round(samp_rate/100)
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: round(samp_rate/100)
    long_form: 'True'
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: luma_fm_carrier
    comment: |-
      ((luma_fm_carrier/Fcc_Fcl)+PLL_shift)*Fcc_Fcl
      firdes.low_pass(1.0, samp_rate,  luma_rate/2, 1e6, firdes.WIN_HAMMING, 6.76 )
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: 10e6
    decim: '1'
    gain: '0.1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e6
    win: firdes.WIN_HAMMING
  states: {}
- name: high_pass_filter_1
  id: high_pass_filter
  parameters:
    cutoff_freq: chroma_adjusted
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: luma_fm_carrier_filter_peak-chroma_adjusted
    win: firdes.WIN_HAMMING
  states: {}
- name: high_pass_filter_2
  id: high_pass_filter
  parameters:
    cutoff_freq: luma_fm_carrier
    decim: '1'
    gain: comb_gain
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e6
    win: firdes.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from string import Formatter
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '1'
    gain: '0.2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: chroma_adjusted - 375e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 8e6-luma_fm_carrier_filter_peak
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: luma_fm_carrier-100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 100e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: luma_fm_carrier-100e3
    decim: '1'
    gain: sharpener
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 100e3
    win: firdes.WIN_HAMMING
  states: {}
- name: luma_gain_signal
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: luma_max
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: luma_min
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: nearest
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\nfrom math import log\n\ndef power(value, base):\n\tn = round(log(value,base))\n\treturn pow(base,n)\t\n\n\t\n"
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@2
    name: '"Y demodulated"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@4
    name: '"Luma band"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@2
    label1: Luma Gain
    max: '0.2'
    min: '0'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@0
    size: '4096'
    srate: round(samp_rate/interpolator)
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_time_sink_x_2_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    gui_hint: tabs@2
    legend: 'False'
    name: '"Luma adjusted"'
    size: round(2*samp_rate/Fh)
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@5
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interpolator
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(display_scale).limit_denominator(1000).numerator
    interp: Fraction(display_scale).limit_denominator(1000).denominator
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_2_1
  id: rational_resampler_xxx
  parameters:
    decim: interpolator
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Chroma Phase
    label1: Head Sync
    label2: Luminance
    label3: PLL
    label4: Vectorscope
    label5: Output
    num_tabs: '6'
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: round(disp_width * 3/4)
    display_width: round(disp_width)
    fps: Fv/2
    height: round(disp_height)
    type: byte
    width: round(disp_width)
  states: {}
- name: virtual_sink_10
  id: virtual_sink
  parameters:
    stream_id: luma_band
  states: {}
- name: virtual_sink_11
  id: virtual_sink
  parameters:
    stream_id: luma_log
  states: {}
- name: virtual_sink_14
  id: virtual_sink
  parameters:
    stream_id: front_raw
  states: {}
- name: virtual_sink_9
  id: virtual_sink
  parameters:
    stream_id: luma_demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: luma_log
  states: {}
- name: virtual_source_11
  id: virtual_source
  parameters:
    stream_id: luma_demod
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    stream_id: luma_band
  states: {}
- name: virtual_source_9
  id: virtual_source
  parameters:
    stream_id: luma_demod
  states: {}

connections:
- [analog_agc2_xx_0, '0', high_pass_filter_0, '0']
- [analog_agc2_xx_0, '0', high_pass_filter_1, '0']
- [analog_agc2_xx_0, '0', low_pass_filter_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_2, '0', blocks_divide_xx_0, '0']
- [analog_fm_deemph_0_0, '0', blocks_add_xx_2, '0']
- [analog_fm_deemph_0_0, '0', high_pass_filter_2, '0']
- [analog_fm_preemph_0, '0', low_pass_filter_2_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0_0, '0']
- [analog_rail_ff_0, '0', qtgui_time_sink_x_2_2, '0']
- [analog_rail_ff_0, '0', virtual_sink_11, '0']
- [analog_rail_ff_0_0, '0', luma_gain_signal, '0']
- [analog_rail_ff_0_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [analog_rail_ff_1, '0', blocks_stream_to_vector_1, '0']
- [band_reject_filter_0, '0', blocks_add_xx_2_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_6, '0']
- [blocks_add_const_vxx_1_0_0, '0', analog_rail_ff_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_10, '0']
- [blocks_add_xx_2, '0', analog_fm_preemph_0, '0']
- [blocks_add_xx_2, '0', band_reject_filter_0, '0']
- [blocks_add_xx_2_0, '0', low_pass_filter_2, '0']
- [blocks_delay_0, '0', blocks_add_xx_2, '1']
- [blocks_divide_xx_0, '0', analog_rail_ff_0_0, '0']
- [blocks_divide_xx_0, '0', qtgui_number_sink_1, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_complex_0, '0', analog_agc2_xx_0, '0']
- [blocks_float_to_uchar_0_0, '0', video_sdl_sink_0, '0']
- [blocks_max_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_min_xx_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_2, '0']
- [blocks_moving_average_xx_0, '0', luma_max, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_sub_xx_2, '1']
- [blocks_moving_average_xx_0_0, '0', luma_min, '0']
- [blocks_multiply_const_vxx_6, '0', dc_blocker_xx_0_0, '0']
- [blocks_multiply_const_vxx_7_0, '0', rational_resampler_xxx_2, '0']
- [blocks_stream_to_vector_1, '0', blocks_max_xx_0, '0']
- [blocks_stream_to_vector_1_0, '0', blocks_min_xx_0, '0']
- [blocks_sub_xx_2, '0', blocks_divide_xx_0, '1']
- [blocks_uchar_to_float_0, '0', dc_blocker_xx_0, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_14, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0, '0']
- [dc_blocker_xx_0_0, '0', blocks_add_const_vxx_1_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [high_pass_filter_0, '0', blocks_add_xx_0, '2']
- [high_pass_filter_1, '0', low_pass_filter_1, '0']
- [high_pass_filter_2, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_add_xx_0, '1']
- [low_pass_filter_1, '0', blocks_add_xx_0, '0']
- [low_pass_filter_2, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_2, '0', virtual_sink_9, '0']
- [low_pass_filter_2_0, '0', blocks_add_xx_2_0, '1']
- [rational_resampler_xxx_0, '0', blocks_float_to_complex_0, '0']
- [rational_resampler_xxx_2, '0', blocks_float_to_uchar_0_0, '0']
- [rational_resampler_xxx_2_1, '0', blocks_file_sink_2, '0']
- [rational_resampler_xxx_2_1, '0', blocks_multiply_const_vxx_7_0, '0']
- [rational_resampler_xxx_2_1, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_2_1, '0']
- [virtual_source_11, '0', blocks_add_const_vxx_0, '0']
- [virtual_source_7, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_7, '0', qtgui_freq_sink_x_0_0_1, '0']
- [virtual_source_7, '0', qtgui_waterfall_sink_x_1_0, '0']
- [virtual_source_9, '0', analog_rail_ff_0_0_0, '0']
- [virtual_source_9, '0', analog_rail_ff_1, '0']

metadata:
  file_format: 1
