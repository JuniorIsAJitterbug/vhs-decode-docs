options:
  parameters:
    author: VideoMem
    copyright: Not your BUSINESS
    description: ( ͡° ͜ʖ ͡°)
    generate_options: qt_gui
    id: VHS_HiFie
    output_language: python
    title: VHS HI-FIe
  states: {}

blocks:
- name: Fh
  id: variable
  parameters:
    comment: |-
      15.625e3 (PAL)
      15.734e3 (NTSC)
    value: 15.625e3
  states: {}
- name: L_carrier
  id: variable
  parameters:
    value: 1.4e6 + carrierL_fine + center_freq
  states: {}
- name: R_carrier
  id: variable
  parameters:
    value: 1.8e6 + carrierR_fine + center_freq
  states: {}
- name: VCO_deviation
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: carrierL_fine
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:1,0,1,1
    label: L Fine Tune
    orient: Qt.Horizontal
    start: '-100e3'
    step: '1'
    stop: 100e3
    value: '0'
  states: {}
- name: carrierR_fine
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@0: 2,0,1,1'
    label: R Fine Tune
    orient: Qt.Horizontal
    start: '-100e3'
    step: '1'
    stop: 100e3
    value: '0'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0,1,1
    label: Center Fine
    min_len: '300'
    orient: Qt.Horizontal
    start: '-30e3'
    step: '0.1'
    stop: 30e3
    value: '-2608.700'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 2*(22e3+VCO_deviation)
  states: {}
- name: half_VCO_deviation
  id: variable
  parameters:
    value: VCO_deviation/2
  states: {}
- name: high_cutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1
    label: BPF High Cutoff
    min_len: '300'
    orient: Qt.Horizontal
    start: '1400000'
    step: '1'
    stop: '1800000'
    value: '1405000'
  states: {}
- name: if_rate
  id: variable
  parameters:
    value: samp_rate/8
  states: {}
- name: low_cutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1
    label: BPF Low Cutoff
    min_len: '300'
    orient: Qt.Horizontal
    start: '1000000'
    step: '1'
    stop: '1400000'
    value: '1395000'
  states: {}
- name: op_VCO_deviation
  id: variable
  parameters:
    value: VCO_deviation/3
  states: {}
- name: q_tip
  id: variable
  parameters:
    value: L_carrier+ abs(L_carrier-R_carrier)/2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 35.8e6
  states: {}
- name: samp_rate_100
  id: variable
  parameters:
    value: samp_rate/100
  states: {}
- name: samp_rate_100_5
  id: variable
  parameters:
    value: samp_rate/100/5
  states: {}
- name: sharpness
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Transition
    min_len: '300'
    orient: Qt.Horizontal
    rangeType: int
    start: int(op_VCO_deviation/4)
    step: '1'
    stop: int(op_VCO_deviation*2)
    value: round(op_VCO_deviation/2)
  states: {}
- name: system
  id: variable
  parameters:
    value: '0'
  states: {}
- name: trans_width
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1
    label: Band Pass Filter Sharpness
    min_len: '300'
    orient: Qt.Horizontal
    rangeType: int
    start: '1000'
    step: '1'
    stop: '500000'
    value: '200000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,1,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.7'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: 1/Fh
    decay_rate: 1/Fh
    gain: '1'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: 1/Fh
    decay_rate: 1/Fh
    gain: '1'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {}
- name: analog_agc2_xx_0_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: 1/Fh
    decay_rate: 1/Fh
    gain: '1'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: if_rate
    tau: '50e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: if_rate
    tau: '50e-6'
  states: {}
- name: analog_fm_deemph_0_0_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate_100_5
    tau: '20e-6'
  states: {}
- name: analog_fm_deemph_0_0_0_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate_100_5
    tau: '20e-6'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '7000'
    audio_stop: '120000'
    chan_rate: samp_rate_100
    deviation: '1000000'
    gain: '1'
    tau: '56e-6'
  states: {}
- name: analog_fm_demod_cf_0_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '7000'
    audio_stop: '120000'
    chan_rate: samp_rate_100
    deviation: '1000000'
    gain: '1'
    tau: '56e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: if_rate/(2*math.pi*VCO_deviation/8.0)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: if_rate/(2*math.pi*VCO_deviation/8.0)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: L_carrier
    offset: '0'
    phase: '0'
    samp_rate: if_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: R_carrier
    offset: '0'
    phase: '0'
    samp_rate: if_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: round(audio_rate)
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: audio_rate
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: '1'
    high_cutoff_freq: L_carrier + op_VCO_deviation/2
    low_cutoff_freq: L_carrier - op_VCO_deviation/2
    samp_rate: if_rate
    type: fir_filter_ccf
    width: sharpness
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: '1'
    high_cutoff_freq: R_carrier + op_VCO_deviation / 2
    low_cutoff_freq: R_carrier - op_VCO_deviation / 2
    samp_rate: if_rate
    type: fir_filter_ccf
    width: sharpness
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    beta: '5'
    decim: '100'
    gain: '1'
    high_cutoff_freq: high_cutoff+4e5+system+center_freq
    low_cutoff_freq: low_cutoff+4e5+system+center_freq
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: trans_width
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    alias: Test
    beta: '5'
    decim: '100'
    gain: '1'
    high_cutoff_freq: high_cutoff+system+center_freq
    low_cutoff_freq: low_cutoff+system+center_freq
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: trans_width
    win: firdes.WIN_KAISER
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/sebastian/Downloads/VTR/vhs_pal_multiburst/test.r8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '4096'
    max_iter: '4000'
    scale: 1/4096
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '4096'
    max_iter: '4000'
    scale: 1/4096
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: '4096'
    max_iter: '4000'
    scale: 1/4096
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1_0
  id: blocks_moving_average_xx
  parameters:
    length: '4096'
    max_iter: '4000'
    scale: 1/4096
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: bypassed}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: hifie_test.wav
    nchan: '4'
    samp_rate: round(audio_rate)
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: round(samp_rate/100)
    long_form: 'True'
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: L_carrier
    comment: firdes.low_pass(1, if_rate, sharpness, 10e3, firdes.WIN_KAISER )
    decim: '1'
    samp_rate: if_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: R_carrier
    comment: firdes.low_pass(1, if_rate, sharpness, 10e3, firdes.WIN_KAISER )
    decim: '1'
    samp_rate: if_rate
    taps: '1'
    type: ccc
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    beta: '5'
    cutoff_freq: '15'
    decim: '1'
    gain: '7.5'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '5'
    win: firdes.WIN_KAISER
  states: {}
- name: high_pass_filter_0_0
  id: high_pass_filter
  parameters:
    beta: '5'
    cutoff_freq: '15'
    decim: '1'
    gain: '7.5'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '5'
    win: firdes.WIN_KAISER
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '5'
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '4000'
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    beta: '5'
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '4000'
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    beta: '5'
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '4000'
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    beta: '5'
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '4000'
    win: firdes.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: if_rate
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@0
    legend: 'False'
    nconnections: '3'
    type: float
    wintype: firdes.WIN_KAISER
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0:1,1,1,1
    min: '0'
    name: '"Left"'
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@1
    min: '0'
    name: '"Left"'
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 'tabs@0: 2,1,1,1'
    min: '0'
    name: '"Right"'
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_number_sink_0_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@1
    min: '0'
    name: '"Right"'
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1
    name: '"Main"'
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1
    name: '"Control"'
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(if_rate/samp_rate).limit_denominator(1000).denominator
    interp: Fraction(if_rate/samp_rate).limit_denominator(1000).numerator
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(audio_rate/samp_rate_100_5).limit_denominator(1000).denominator
    interp: Fraction(audio_rate/samp_rate_100_5).limit_denominator(1000).numerator
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(audio_rate/samp_rate_100_5).limit_denominator(1000).denominator
    interp: Fraction(audio_rate/samp_rate_100_5).limit_denominator(1000).numerator
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(audio_rate/if_rate).limit_denominator(1000).denominator
    interp: Fraction(audio_rate/if_rate).limit_denominator(1000).numerator
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(audio_rate/if_rate).limit_denominator(1000).denominator
    interp: Fraction(audio_rate/if_rate).limit_denominator(1000).numerator
    taps: ''
    type: fff
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Main
    label1: Control
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: AGC_if
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rf
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: L
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: R
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: CH0
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: CH1
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: Z_L
  states: {}
- name: virtual_sink_4_0
  id: virtual_sink
  parameters:
    stream_id: Z_R
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: AGC_if
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: CH0
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: CH1
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: rf
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: Z_R
  states: {}
- name: virtual_source_6_0
  id: virtual_source
  parameters:
    stream_id: Z_R
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    stream_id: Z_L
  states: {}
- name: virtual_source_7_0
  id: virtual_source
  parameters:
    stream_id: Z_L
  states: {}

connections:
- [analog_agc2_xx_0, '0', virtual_sink_0, '0']
- [analog_agc2_xx_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_agc2_xx_0_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [analog_fm_deemph_0, '0', rational_resampler_xxx_1, '0']
- [analog_fm_deemph_0_0, '0', rational_resampler_xxx_1_0, '0']
- [analog_fm_deemph_0_0_0_0, '0', rational_resampler_xxx_0_0_0_0_0, '0']
- [analog_fm_deemph_0_0_0_0_0, '0', rational_resampler_xxx_0_0_0_0_0_1, '0']
- [analog_fm_demod_cf_0, '0', analog_fm_deemph_0_0_0_0, '0']
- [analog_fm_demod_cf_0_0, '0', analog_fm_deemph_0_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', analog_fm_deemph_0_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_sig_source_x_0_0, '0', qtgui_freq_sink_x_0, '2']
- [band_pass_filter_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [band_pass_filter_0, '0', virtual_sink_3, '0']
- [band_pass_filter_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [band_pass_filter_0_0, '0', virtual_sink_2, '0']
- [band_pass_filter_0_0_0, '0', analog_fm_demod_cf_0_0, '0']
- [band_pass_filter_0_1, '0', analog_fm_demod_cf_0, '0']
- [blocks_abs_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_abs_xx_0_0, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_abs_xx_0_0_0, '0', blocks_moving_average_xx_0_1_0, '0']
- [blocks_abs_xx_0_1, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_add_xx_1, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_complex_0, '0', analog_agc2_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_moving_average_xx_0_1, '0', qtgui_number_sink_0_1, '0']
- [blocks_moving_average_xx_0_1_0, '0', qtgui_number_sink_0_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_abs_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_abs_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', virtual_sink_4_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', virtual_sink_4, '0']
- [blocks_null_source_0, '0', virtual_sink_4, '0']
- [blocks_null_source_0, '0', virtual_sink_4_0, '0']
- [blocks_throttle_0, '0', dc_blocker_xx_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_throttle_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_agc2_xx_0_0_0, '0']
- [high_pass_filter_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [high_pass_filter_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [low_pass_filter_0, '0', high_pass_filter_0, '0']
- [low_pass_filter_0_0, '0', high_pass_filter_0_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [low_pass_filter_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_complex_0, '0']
- [rational_resampler_xxx_0_0_0_0_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0_0_0_0_1, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_0_1, '0']
- [rational_resampler_xxx_1_0, '0', low_pass_filter_0_0_0, '0']
- [virtual_source_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', band_pass_filter_0_0, '0']
- [virtual_source_1, '0', audio_sink_0, '0']
- [virtual_source_1, '0', blocks_wavfile_sink_0, '0']
- [virtual_source_1_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_2, '0', audio_sink_0, '1']
- [virtual_source_2, '0', blocks_wavfile_sink_0, '1']
- [virtual_source_2_0, '0', qtgui_waterfall_sink_x_0, '1']
- [virtual_source_3, '0', blocks_add_xx_1, '0']
- [virtual_source_4, '0', blocks_add_xx_1, '1']
- [virtual_source_5, '0', band_pass_filter_0_0_0, '0']
- [virtual_source_5, '0', band_pass_filter_0_1, '0']
- [virtual_source_6, '0', blocks_abs_xx_0_0_0, '0']
- [virtual_source_6, '0', blocks_wavfile_sink_0, '3']
- [virtual_source_6_0, '0', qtgui_waterfall_sink_x_0_0, '1']
- [virtual_source_7, '0', blocks_abs_xx_0_1, '0']
- [virtual_source_7, '0', blocks_wavfile_sink_0, '2']
- [virtual_source_7_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
